FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Patch-lopper-to-avoid-removing-fclk-from-DT.patch"

