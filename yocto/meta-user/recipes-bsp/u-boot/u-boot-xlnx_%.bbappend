FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://usr-u-boot.cfg"
