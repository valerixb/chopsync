#
# This recipe replaces standard xilinx wic image partition scheme
# with the one defined in kickstart file:
# maxiv-edf-disk-single-rootfs.wks
#

WKS_FILES = "maxiv-edf-disk-single-rootfs.wks"
